# IAR project eboot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136K8TA HDSC HC32L136K8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; ..\chip\lib_hc32l13x; ..\chip\lib_hc32l13x\common; ..\chip\lib_hc32l13x\driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: eboot.out
  ILINK.IlinkIcfFile: hc32l13x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_bootload.c app_bootload.h app_cfg.h app_mbus.c app_mbus.h app_protocol_easyink.c app_protocol_easyink.h main.c
  group chip
    ../chip/lib_hc32l13x/common/: interrupts_hc32l13x.c system_hc32l13x.c
    ../chip/lib_hc32l13x/: startup_hc32l13x.s
  group mde/mde_mbus_link
    ../mde/mde_mbus_link/: bsp_mbus_link.c bsp_mbus_link.h bsp_mbus_link_hc32l136k8ta.h mde_mbus_link.c mde_mbus_link.h mde_mbus_link_match.h
  group mde/mde_storage_small
    ../mde/mde_storage_small/: bsp_storage_small.c bsp_storage_small.h mde_storage_small.c mde_storage_small.h
  group mde/mde_update_files
    ../mde/mde_update_files/: bsp_update_files.c bsp_update_files.h mde_update_files.c mde_update_files.h
  group mde/mde_watchdog
    ../mde/mde_watchdog/: bps_watchdog.c bps_watchdog.h mde_watchdog.c mde_watchdog.h
  group pbc/pbc_data_convert
    ../pbc/pbc_data_convert/: pbc_data_convert.c pbc_data_convert.h
  group pbc/pbc_tick_small
    ../pbc/pbc_tick_small/: bsp_tick_small.c bsp_tick_small.h bsp_tick_small_hc32l136k8ta.h pbc_tick_small.c pbc_tick_small.h
