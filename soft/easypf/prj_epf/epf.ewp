# IAR project epf.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136K8TA HDSC HC32L136K8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; ..\chip\lib_hc32l13x; ..\chip\lib_hc32l13x\common; ..\chip\lib_hc32l13x\driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: epf.out
  ILINK.IlinkIcfFile: hc32l13x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_cfg.h app_epf_message.c app_epf_message.h main.c
  group chip
    ../chip/lib_hc32l13x/common/: interrupts_hc32l13x.c system_hc32l13x.c
    ../chip/lib_hc32l13x/: startup_hc32l13x.s
  group mde/mde_epf_accpet
    ../mde/mde_epf_accpet/: bsp_epf_accpet.c bsp_epf_accpet.h bsp_epf_accpet_hc32l136k8ta.h mde_epf_accpet.c mde_epf_accpet.h
  group mde/mde_pilot_light
    ../mde/mde_pilot_light/: bsp_pilot_light.c bsp_pilot_light.h mde_pilot_light.c mde_pilot_light.h mde_pilot_light_match.h
  group mde/mde_rmcd_char
    ../mde/mde_rmcd_char/: bsp_rmcd_char.c bsp_rmcd_char.h bsp_rmcd_char_hc32l136k8ta.h mde_rmcd_char.c mde_rmcd_char.h
  group pbc/pbc_data_convert
    ../pbc/pbc_data_convert/: pbc_data_convert.c pbc_data_convert.h
  group pbc/pbc_tick_small
    ../pbc/pbc_tick_small/: bsp_tick_small.c bsp_tick_small.h bsp_tick_small_hc32l136k8ta.h pbc_tick_small.c pbc_tick_small.h
